# Keil uVision project test.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.4.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: E:\real system projects\ultrasonic system
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x2000
  group Source Group 1
    ./: 0.c pwm.c adc.c lcd.c button.c page_0.c menu.c code.c circle_machine.c page_1_bar_time.c r1.c dec_inc.c f34x.c touch.c debug_uart.c timers.c
software components: CMSIS:CORE 4.1.0, Device:Startup 1.0.0
